options:
  parameters:
    generate_options: qt_gui
    id: ssb_rx
    output_language: python
    title: SSB Receiver
  states: {}

blocks:
- name: agc_attack
  id: variable_qtgui_range
  parameters:
    label: AGC Attack
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.001'
    stop: '0.3'
    value: '0.1'
  states: {}
- name: agc_decay
  id: variable_qtgui_range
  parameters:
    label: AGC Decay
    orient: Qt.Horizontal
    start: '10e-06'
    step: '1e-06'
    stop: '100e-06'
    value: '65e-06'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 14.2e6
  states: {}
- name: decimate
  id: variable
  parameters:
    value: '5'
  states: {}
- name: filter_width
  id: variable
  parameters:
    value: 1.2e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Vertical
    start: '0'
    step: '1000'
    stop: '30000'
    value: '10000'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    label: Tune
    orient: Qt.Horizontal
    start: '-25000'
    step: '1000'
    stop: '25000'
    value: '-1300'
    widget: slider
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_range_0_0_0_0_0_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
    widget: slider
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: agc_attack
    decay_rate: agc_decay
    gain: '1'
    max_gain: '1'
    reference: '.3'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: filter_width
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/(decimate*decimate)
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: filter_width
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/(decimate*decimate)
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    alias: RF Gain
    const: gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\lucas\OneDrive\Documentos\2002_ERE\Ivan\TrabalhoPrincipios\Trabalho_AM_SSB\wav_music.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: tuner
    decim: decimate
    samp_rate: samp_rate/decimate
    taps: firdes.low_pass(1, 50e3 ,filter_width-200, 300)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '16'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decimate
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_1, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fft_filter_ccc_0, '0', analog_agc2_xx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
