options:
  parameters:
    author: lucas
    generate_options: qt_gui
    id: ssb_tx_lucas_v1
    output_language: python
    title: SSB TX
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: 30e3
  states: {}
- name: fstart
  id: variable
  parameters:
    value: '200'
  states: {}
- name: input_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 88.2e3
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '200'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0.5'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: carrier_freq + signal_bandwidth
    low_cutoff_freq: carrier_freq + fstart
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: carrier_freq + signal_bandwidth
    low_cutoff_freq: carrier_freq + fstart
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 44.1e3
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\lucas\OneDrive\Documentos\2002_ERE\Ivan\TrabalhoPrincipios\Trabalho_AM_SSB\wav_music.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\lucas\OneDrive\Documentos\2002_ERE\Ivan\TrabalhoPrincipios\Trabalho_AM_SSB\sweep.wav
    repeat: 'True'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.000010'
    freq_offset: '0.0'
    noise_voltage: '0.001'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_bandwidth
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_bandwidth
    decim: '1'
    gain: '1'
    samp_rate: '44100'
    type: fir_filter_fff
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '44100'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"FilterOutTX"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"MixerOut"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"AudioResampled"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_2_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX_Product"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_2_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX_audio"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_2_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    name: '"RX_audio_sink"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_2_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX_in_FFT"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_2_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"LO"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_2_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    name: '"AudioThrottle"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '2'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mixer_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: TX_out
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mixer_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: TX_out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: RX_in
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_waterfall_sink_x_2_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', band_pass_filter_0_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [band_pass_filter_0_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_float_0, '0', virtual_sink_2, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_waterfall_sink_x_2_0, '0']
- [blocks_throttle_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_waterfall_sink_x_2_2, '0']
- [blocks_wavfile_source_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_waterfall_sink_x_2_2, '0']
- [channels_channel_model_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_2_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_2, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_waterfall_sink_x_2_0_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [virtual_source_1, '0', blocks_float_to_complex_0, '0']
- [virtual_source_2, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_2, '0', qtgui_waterfall_sink_x_2_0_1, '0']

metadata:
  file_format: 1
