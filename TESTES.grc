options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: source
  id: variable_qtgui_chooser
  parameters:
    label: Input Select
    label0: Sine Wave
    label1: Music_ch1
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: '10000000'
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1100000'
    low_cutoff_freq: '900000'
    samp_rate: '10000000'
    type: fir_filter_ccf
    width: '50000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Program Files\GNURadio-3.8\bin\wav_music.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    name: '"Message FFT"'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-160'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '300000'
    fc: '0'
    fftsize: '1024'
    name: '"modulated"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '1']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_selector_0, '0', blocks_multiply_xx_0, '1']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
