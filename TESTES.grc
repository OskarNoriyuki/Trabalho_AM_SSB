options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: W
  id: variable
  parameters:
    value: 20e03
  states: {}
- name: carrier_f
  id: variable
  parameters:
    value: 5e05
  states: {}
- name: carrier_samp_rate
  id: variable
  parameters:
    value: 20e06
  states: {}
- name: message_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: source
  id: variable_qtgui_chooser
  parameters:
    label: Input Select
    label0: Sine Wave
    label1: Music_ch1
    label2: Realtek_Audio
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: message_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: W/2
    offset: '0'
    phase: '0'
    samp_rate: message_samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_f-W/2
    offset: '0'
    phase: '0'
    samp_rate: carrier_samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '100'
    samp_rate: message_samp_rate
    type: fir_filter_ccf
    width: '50'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Program Files\GNURadio-3.8\bin\wav_music.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: W/2
    decim: '1'
    gain: '1'
    samp_rate: message_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: W/2
    decim: '1'
    gain: '1'
    samp_rate: message_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: message_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Message FFT"'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-160'
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: carrier_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"modulated"'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [analog_sig_source_x_1, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_1_1, '0', blocks_complex_to_float_0_0, '0']
- [analog_sig_source_x_1_1, '0', blocks_multiply_xx_1_0, '1']
- [audio_source_0, '0', blocks_float_to_complex_1, '0']
- [band_pass_filter_1, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_1, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_complex_to_float_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_float_0_0, '0', hilbert_fc_1, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '1']
- [blocks_float_to_complex_1, '0', blocks_selector_0, '2']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1_0_0, '0', blocks_add_xx_0, '1']
- [blocks_selector_0, '0', band_pass_filter_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [hilbert_fc_1, '0', blocks_multiply_xx_1_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_1_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_xx_1_0_0, '1']

metadata:
  file_format: 1
