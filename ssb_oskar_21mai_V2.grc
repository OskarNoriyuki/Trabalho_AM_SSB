options:
  parameters:
    author: oskar
    generate_options: qt_gui
    id: ssb_oskar_21_V2mai
    output_language: python
    title: ssb_oskar_21_V2mai
  states: {}

blocks:
- name: agc_attack
  id: variable_qtgui_range
  parameters:
    label: AGC Attack
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.001'
    stop: '0.3'
    value: '0.1'
  states: {}
- name: agc_decay
  id: variable_qtgui_range
  parameters:
    label: AGC Decay
    orient: Qt.Horizontal
    start: '10e-06'
    step: '1e-06'
    stop: '100e-06'
    value: '65e-06'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 500E3
  states: {}
- name: f_error
  id: variable_qtgui_range
  parameters:
    label: frequency deviation (LC error)
    orient: Qt.Horizontal
    start: '0'
    step: '1e-03'
    stop: '1'
    value: '0'
  states: {}
- name: input_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2000E3
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: agc_attack
    decay_rate: agc_decay
    gain: '1'
    max_gain: '1'
    reference: '.5'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: carrier_freq*(1+f_error)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*(1+f_error)
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: carrier_freq*(1+f_error)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*(1+f_error)
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: carrier_freq+20500
    low_cutoff_freq: carrier_freq+500
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: input_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 44.1e3
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Program Files\GNURadio-3.8\bin\wav_music.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\lucas\OneDrive\Documentos\2002_ERE\Ivan\TrabalhoPrincipios\Trabalho_AM_SSB\sweep.wav
    repeat: 'True'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '1'
    noise_voltage: '0.1'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*(1+f_error)
    type: fir_filter_ccf
    width: '6000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"AfterFilter"'
    type: complex
    wintype: firdes.WIN_HANN
    ymin: '-200'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '10240'
    name: '"BeforeFilter"'
    type: complex
    wintype: firdes.WIN_HANN
    ymin: '-200'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"message scope"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"modulated scope"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RX IN scope"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RX OUT scope"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"LOWER SIDEBAND SUPRESSED"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    name: '"receptor"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"mixer_out"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX_in"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(44100/100)
    fbw: '0.4'
    interp: int(carrier_freq/100)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(carrier_freq/100)
    interp: int(44100/100)
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mixer_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mixer_out
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: channel_out
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_agc2_xx_0, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_1, '0', hilbert_fc_0, '0']
- [band_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_complex_2, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_float_1, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_float_2, '0', virtual_sink_0_0, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [blocks_float_to_complex_2, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_throttle_0_0_0, '0']
- [channels_channel_model_0, '0', blocks_complex_to_float_2, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_2, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [virtual_source_0_0, '0', analog_agc2_xx_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
